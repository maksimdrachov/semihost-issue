## testcase.yaml
```yaml
tests:
  verification.integration.semihost:
    arch_allow: arm
    build_only: false
    # platform_type:
    #   - qemu
```
